# Keil uVision project WLSJ-STM32.uvproj, settings and files
target WLSJ-STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WLSJ-STM32 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\User;..\Core;..\System\SYS;..\System\DELAY;..\System\IIC;..\System\USART;..\Hardware\LINE;..\Hardware\MOTOR;..\Hardware\SENSOR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c
  group Core
    ../Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    ../Hardware/LINE/: line.c
    ../Hardware/MOTOR/: motor.c
    ../Hardware/SENSOR/: sensor.c
  group System
    ../System/DELAY/: delay.c
    ../System/SYS/: sys.c
    ../System/IIC/: iic.c
    ../System/USART/: usart.c
